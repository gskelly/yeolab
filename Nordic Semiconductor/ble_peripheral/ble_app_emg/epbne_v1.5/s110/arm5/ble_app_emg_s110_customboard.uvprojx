# Keil uVision project ble_app_emg_s110_customboard.uvprojx, settings and files
target nrf51422_xxac_s110 (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.7.1.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: epcustom_nrf51422_xxac_s110 +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  AfterMake: C:\Program Files (x86)\Nordic Semiconductor\Master Control Panel\3.9.0.6\nrf\nrf.exe dfu genpkg "C:\Users\Graham\Google Drive\nRF51 Firmware Images\@L.zip" --application @L.bin --application-version 0xffff --dev-revision 0xffff --dev-type 0xffff --sd-req 0x0064
  c flags: Optim=4 oTime=1 OneElfS=1
  c define: NRF51 BLE_STACK_SUPPORT_REQD S110 SOFTDEVICE_PRESENT BOARD_PCA10028 BLE_DFU_APP_SUPPORT SPI_MASTER_0_ENABLE ADS1291
  c misc: --c99
  c include: ..\..\..\config
  library: MicroLIB
  memory RVCT4: ROM 0x18000 size 0x28000
  memory RVCT9: RAM 0x20002000 size 0x6000
  group Application
    ../../../: main.c
    ./RTE/: ble_bms.c
    ./: ads1291-2.c
  group Documentation
    ../../../: Abstract.txt license.txt
  group Boards
    ./RTE/: bne_emg_v1_5.h
software components: CMSIS:CORE 3.40.0, Board Support:bsp 8.0.0, Device:Startup 7.1.0, nRF_BLE:BLE_Modules:ble_advdata 2.0.0, nRF_BLE:BLE_Modules:ble_common 2.0.0, nRF_BLE:BLE_Modules:ble_conn_params 2.0.0, nRF_BLE:BLE_Modules:ble_service_common 2.0.0, nRF_BLE:BLE_Modules:device_manager 2.0.0, nRF_BLE:BLE_Services:ble_bas 2.0.0, nRF_BLE:BLE_Services:ble_dfu 2.0.0, nRF_BLE:BLE_Services:ble_dis 2.0.0, nRF_Drivers:app_uart 2.0.0, nRF_Drivers:nrf_adc 2.0.0, nRF_Drivers:nrf_delay 2.0.0, nRF_Drivers:nrf_error 2.0.0, nRF_Drivers:nrf_gpio 2.0.0, nRF_Drivers:nrf_soc 2.0.0, nRF_Drivers:pstorage 2.0.0, nRF_Drivers:spi_master 2.0.0, nRF_Libraries:DFU:dfu_app_handler 2.0.0, nRF_Libraries:DFU:dfu_bootloader_util 2.0.0, nRF_Libraries:app_button 2.0.0, nRF_Libraries:app_error 2.0.0, nRF_Libraries:app_gpiote 2.0.0, nRF_Libraries:app_scheduler 2.0.0, nRF_Libraries:app_timer 2.0.0, nRF_Libraries:app_trace 2.0.0, nRF_Libraries:app_util 2.0.0, nRF_Libraries:nrf_assert 2.0.0, nRF_Libraries:retarget 2.0.0, nRF_Libraries:sensorsim 2.0.0, nRF_SoftDevice:Internal:sd_common 1.1.2, nRF_SoftDevice:Internal:softdevice_present 1.1.2, nRF_SoftDevice:s110 8.0.0
