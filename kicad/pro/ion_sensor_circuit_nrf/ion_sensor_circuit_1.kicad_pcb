# Repository gskelly/yeolab

## KiCad design kicad/pro/ion_sensor_circuit_nrf/ion_sensor_circuit_1.kicad_pcb

Parts:
A1: CHIP-ANT
B1: 2450BM14E0003
BT1: BATTERY
C1: 10uF
C3: 0.01uF
C5, C8: 1uF
C6: 4.7uF
C7, C11: 0.1uF
C9, C10: 12pF 2%
C12: 47nF
C13: 1000pF
C14: 2200pF
C15: 1.0pF
D1: RB021VA90TR
L1: 15nH
L2: 10uH
L3: 2.7nH
L4: 3.9nH
P1: BEETRODE
P2: CONN_2
R1: 22k
R4, R5: 10k
U1: TSU101ICT
U3: NRF51X22-QFN
X1: 16MHz

Connections:
/ANT1: B1.4 (BAL2), U3.31
/ANT2: B1.3 (BAL1), U3.32
/DCC: L2.1, U3.2
/DEC1: C11.1, U3.39
/DEC2: C12.1, U3.29
/PH_IN+: P1.2 (PM), R1.1
/PH_OUT: C5.1, R4.1, U1.4 (VOUT), U3.18
/RF: B1.1 (UBAL), C15.1
/SWDCLK: P2.1, U3.24
/SWDIO: P2.2 (PM), U3.23
/VDD_PA: B1.5 (DC), C14.1, U3.30
/XC1: C9.2, U3.37, X1.1
/XC2: C10.2, U3.38, X1.3
GND: B1.2 (GND), B1.6 (GND), BT1.2 (-), C1.2, C3.2, C5.2, C6.2, C7.2, C8.2, C9.1, C10.1, C11.2, C12.2, C13.2, C14.2, L3.2, P1.1, R5.2, U1.2 (-VS), U3.13, U3.33, U3.34, X1.2 (GND), X1.4 (GND)
unnamed: C1.1, R1.2, U1.1 (+IN)
unnamed: BT1.1 (+), D1.1 (A)
unnamed: R4.2, R5.1, U1.3 (-IN)
unnamed: A1.1 (ANT), L4.2
unnamed: C15.2, L3.1, L4.1
unnamed: L1.1, L2.2
VAA: C8.1, C13.1, L1.2, U3.35, U3.36
VCC: C3.1, C6.1, C7.1, D1.2 (K), U1.5 (+VS), U3.1, U3.12

Notes on the sheet:
This network will need to be tuned
Amplifier G=2
Source resistance will be around 100k for Beetrode. Even if it is lower, this filter ensures at most 0.72 Hz corner frequency
Test Beetrode output range to find out if it goes negative. If so, you will need to offset the voltage at pin 2 to the midpoint of the ADC's input range (1.2V/2)

Board: 2 copper layers, 34.2 x 15.0 mm, 29 parts (0 on the bottom side), 22 nets.

## KiCad design kicad/pro/exg_circuit_qfn/emg_circuit_2_ext_amp.kicad_pcb

Parts:
A1: CHIP-ANT
B1: 2450BM14E0003
C1, C2: 4.7nF
C3, C7, C10, C13, C16: 100nF
C4: 10uF
C5: 1.5nF
C6, C8, C9, C11, C21: 1uF
C12: 4.7uF
C14, C15: 12pF 2%
C17: 47nF
C18: 1nF
C19: 2.2nF
C20: 1.0pF
L1: 2.7nH
L2: 3.9nH
L3: 15nH
L4: 10uH
P1: CONN_2
P2: CONN_5
P6: PWR
R1: 1M
R2, R3, R4: 30k
U1: ADS1291/2
U2: NRF51X22-QFN
X1: 16MHz

Connections:
/ANT1: B1.4 (BAL2), U2.31
/ANT2: B1.3 (BAL1), U2.32
/DCC: L4.1, U2.2
/DEC1: C16.1, U2.39
/DEC2: C17.1, U2.29
/IN1N: R2.2, U1.3 (IN1N)
/IN1P: R3.1, U1.4 (IN1P)
/IN+: P2.3, R3.2
/IN-: P2.5, R2.1
/RF: B1.1 (UBAL), C20.1
/RLD: P2.4, R4.1
/RLDINV: C5.2, R1.2, U1.28 (RLDINV)
/RLDOUT: C5.1, R1.1, R4.2, U1.29 (RLDIN/RLDREF), U1.30 (RLDOUT)
/SPI_MISO: U1.21 (DOUT), U2.18
/SPI_MOSI: U1.19 (DIN), U2.20
/SPI_SCLK: U1.20 (SCLK), U2.19, U2.26
/SPI_~CS: U1.18 (~CS), U2.21, U2.25
/SWDCLK: P2.1, U2.24
/SWDIO: P2.2, U2.23
/VCAP1: C8.1, U1.11 (VCAP1)
/VCAP2: C9.1, U1.27 (VCAP2)
/VDD_PA: B1.5 (DC), C19.1, U2.30
/VREFP: C3.1, C4.1, U1.9 (VREFP)
/XC1: C14.2, U2.37, X1.1
/XC2: C15.2, U2.38, X1.3
/~DRDY: U1.22 (~DRDY), U2.17
/~PWDN/RESET: U1.15 (~PWDN/RESET), U2.22
GND: B1.2 (GND), B1.6 (GND), C3.2, C4.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.1, C15.1, C16.2, C17.2, C18.2, C19.2, C21.2, L1.2, P1.2 (PM), P6.2 (PM), U1.10 (VREFN), U1.13 (AVSS), U1.16 (START), U1.24 (DGND), U2.13, U2.33, U2.34, X1.2 (GND), X1.4 (GND)
unnamed: A1.1 (ANT), L2.2
unnamed: C20.2, L1.1, L2.1
unnamed: L3.1, L4.2
unnamed: C1.2, U1.1 (PGA1N)
unnamed: C1.1, U1.2 (PGA1P)
unnamed: C2.2, U1.7 (PGA2N)
unnamed: C2.1, U1.8 (PGA2P)
VAA: C18.1, C21.1, L3.2, U2.35, U2.36
VCC: C6.1, C7.1, C10.1, C11.1, C12.1, C13.1, P1.1, P6.1, U1.5 (IN2N), U1.6 (IN2P), U1.12 (AVDD), U1.14 (CLKSEL), U1.23 (DVDD), U1.31 (RESP_MODP/IN3P), U1.32 (RESP_MODN/IN3N), U2.1, U2.12

Notes on the sheet:
This network will need to be tuned
Note for future revision: This can be 0402 at 1% tolerance
C8 should be tant, make sure polarity is marked in future revision
No reverse polarity protection; use caution and do not connect battery and debugger at same time!

Board: 2 copper layers, 34.0 x 15.0 mm, 37 parts (1 on the bottom side), 37 nets.

File kicad/pro/exg_circuit_wlcsp/emg_circuit_1_ext_amp_BOM.xlsx:

Val | Ct | Ref | Footprint | Manufacturer | Manufacturer PN | Distributor | Distr PN
CHIP-ANT | 1 | A1 | JTI 2450AT18A100 | Johanson Technology Inc | 2450AT18A100E | Digi-Key | 712-1005-1-ND
BAL-NRF02D3 | 1 | B1 | BAL-NRF02D3 | STMicroelectronics | BAL-NRF02D3 | Digi-Key | 497-14009-1-ND
1.0pF | 1 | C20 | SM0402 | Johanson Technology Inc | 500R07S1R0BV4T | Digi-Key | 712-1266-1-ND
2.7nH | 1 | L1 | SM0402 | Johanson Technology Inc | L-07C2N7SV6T | Digi-Key | 712-1415-1-ND
3.9nH | 1 | L2 | SM0402 | Johanson Technology Inc | L-07C3N9SV6T | Digi-Key | 712-1459-1-ND
12pF 2% | 2 | C14 C15 | SM0402 | Murata Electronics North America | GRM1555C1H120GA01D | Digi-Key | 490-6197-1-ND
1nF | 1 | C18 | SM0402 | Murata Electronics North America | GRM155R71H102KA01D | Digi-Key | 490-1303-1-ND
1.5nF | 1 | C5 | SM0402 | Samsung Electro-Mechanics America, Inc | CL05B152JB5NNNC | Digi-Key | 1276-1518-1-ND
2.2nF | 1 | C19 | SM0402 | Murata Electronics North America | GRM155R71H222KA01D | Digi-Key | 490-1305-1-ND
4.7nF | 2 | C1 C2 | SM0402 | Murata Electronics North America | GRM155R71H472KA01J | Digi-Key | 490-8259-1-ND
47nF | 1 | C17 | SM0402 | Murata Electronics North America | GRM155R71E473KA88D | Digi-Key | 490-3254-1-ND
100nF | 6 | C3 C7 C10 C12 C13 C16 | SM0402 | Murata Electronics North America | GRM155R71C104KA88D | Digi-Key | 490-3261-1-ND
1uF | 3 | C6 C9 C11 | SM0402 | Murata Electronics North America |  | Digi-Key | 490-9665-1-ND
1uF | 1 | C8 | SM0402 | Vishay Sprague | 298D105X0016K2T | Digi-Key | 718-1618-1-ND
10uF | 1 | C4 | SM0402 | Samsung Electro-Mechanics America, Inc |  | Digi-Key | 1276-1451-1-ND
30k | 3 | R2 R3 R4 | SM0402 | Panasonic Electronic Components | ERJ-2GEJ303X | Digi-Key | P30KJCT-ND
1M | 1 | R1 | SM0603 | Panasonic Electronic Components | ERJ-3EKF1004V | Digi-Key | P1.00MHCT-ND
ADS1291/2 | 1 | U1 | VQFN32 | Texas Instruments | ADS1291IRSMT | Digi-Key | ADS1291IRSMT
NRF51X22-CEAA/CFAC | 1 | U2 | CEAA | Nordic Semiconductor | NRF51822-CFAC-R | Digi-Key | 1490-1041-1-ND
16MHz | 1 | X1 | XTAL-2MMx1MM6 | AVX Corp/Kyocera Corp | CX2016DB16000D0FLJCC | Digi-Key | 1253-1348-1-ND
CONN_2 | 1 | P1 | PIN-HEADER-2X1 | - | - | - | -
CONN_5 | 1 | P2 | PIN-HEADER-5X1 | Sullins Connector Solutions | PBC36SFAN | Digi-Key | S1211E-36-ND
PWR | 1 | P6 | 3012TR | Keystone Electronics | 3012TR | Digi-Key | 3012KCT-ND
BATTERY | 1 | - | - | Energizer Battery Company | CR1632VP | Digi-Key | N036-ND
NRF51X22-CEAA/CFAC | 1 | U2 | CEAA | Nordic Semiconductor | NRF51822-CEAA-R (rev 2) | SemiconductorStore.com | NRF51822-CEAA-R_D0

## KiCad design kicad/pro/exg_circuit_wlcsp/emg_circuit_1_ext_amp.kicad_pcb

Parts:
A1: CHIP-ANT
B1: BAL-NRF02D3
C1, C2: 4.7nF
C3, C7, C10, C12, C13, C16: 100nF
C4: 10uF
C5: 1.5nF
C6, C8, C9, C11: 1uF
C14, C15: 12pF 2%
C17: 47nF
C18: 1nF
C19: 2.2nF
C20: 1.0pF
L1: 2.7nH
L2: 3.9nH
P1: CONN_2
P2: CONN_5
P6: PWR
R1: 1M
R2, R3, R4: 30k
U1: ADS1291/2
X1: 16MHz

Connections:
/ANT1: B1.A3 (ANT1); also elsewhere on the board
/ANT2: B1.B3 (ANT2); also elsewhere on the board
/DEC1: C16.1; also elsewhere on the board
/DEC2: C17.1; also elsewhere on the board
/IN1N: R2.2, U1.3 (IN1N)
/IN1P: R3.1, U1.4 (IN1P)
/IN+: P2.1, R3.2
/IN-: P2.3, R2.1
/RF: B1.A1 (SE), C20.1
/RLD: P2.2, R4.1
/RLDINV: C5.2, R1.2, U1.28 (RLDINV)
/RLDOUT: C5.1, R1.1, R4.2, U1.30 (RLDOUT)
/SPI_MISO: U1.21 (DOUT); also elsewhere on the board
/SPI_MOSI: U1.19 (DIN); also elsewhere on the board
/SPI_SCLK: U1.20 (SCLK); also elsewhere on the board
/SPI_~CS: U1.18 (~CS); also elsewhere on the board
/SWDCLK: P2.5; also elsewhere on the board
/SWDIO: P2.4; also elsewhere on the board
/VCAP1: C8.1, U1.11 (VCAP1)
/VCAP2: C9.1, U1.27 (VCAP2)
/VDD_PA: B1.A2 (VDD_PA), C19.1; also elsewhere on the board
/VREFP: C3.1, C4.1, U1.9 (VREFP)
/XC1: C14.2, X1.1; also elsewhere on the board
/XC2: C15.2, X1.3; also elsewhere on the board
/~DRDY: U1.22 (~DRDY); also elsewhere on the board
/~PWDN/RESET: U1.15 (~PWDN/RESET); also elsewhere on the board
GND: B1.B1 (GND), C3.2, C4.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.1, C15.1, C16.2, C17.2, C18.2, C19.2, L1.2, P1.2 (PM), P6.2 (PM), U1.10 (VREFN), U1.13 (AVSS), U1.16 (START), U1.24 (DGND), X1.2 (GND), X1.4 (GND); also elsewhere on the board
unnamed: C2.1, U1.8 (PGA2P)
unnamed: C2.2, U1.7 (PGA2N)
unnamed: C1.1, U1.2 (PGA1P)
unnamed: C1.2, U1.1 (PGA1N)
unnamed: C20.2, L1.1, L2.1
unnamed: A1.1 (ANT), L2.2
VCC: C6.1, C7.1, C10.1, C11.1, C12.1, C13.1, C18.1, P1.1, P6.1, U1.5 (IN2N), U1.6 (IN2P), U1.12 (AVDD), U1.14 (CLKSEL), U1.23 (DVDD), U1.31 (RESP_MODP/IN3P), U1.32 (RESP_MODN/IN3N); also elsewhere on the board

Notes on the sheet:
This network will need to be tuned
Note for future revision: This can be 0402 at 1% tolerance
C8 should be tant, make sure polarity is marked in future revision
No reverse polarity protection; use caution and do not connect battery and debugger at same time!

Board: 2 copper layers, 34.1 x 15.0 mm, 34 parts (1 on the bottom side), 34 nets.

Other parts of the board:
U2: NRF51X22-CEAA/CFAC; CEAA-WLCSP-62

Their connections:
/ANT1: U2.D1; also elsewhere on the board
/ANT2: U2.C1; also elsewhere on the board
/DEC1: U2.A4; also elsewhere on the board
/DEC2: U2.F1; also elsewhere on the board
/SPI_MISO: U2.J4; also elsewhere on the board
/SPI_MOSI: U2.J6; also elsewhere on the board
/SPI_SCLK: U2.J5; also elsewhere on the board
/SPI_~CS: U2.J7; also elsewhere on the board
/SWDCLK: U2.H2; also elsewhere on the board
/SWDIO: U2.J2; also elsewhere on the board
/VDD_PA: U2.E1; also elsewhere on the board
/XC1: U2.A2; also elsewhere on the board
/XC2: U2.A3; also elsewhere on the board
/~DRDY: U2.J3; also elsewhere on the board
/~PWDN/RESET: U2.J8; also elsewhere on the board
GND: U2.B1, U2.B4, U2.C8, U2.D7, U2.G6, U2.G9, U2.H3; also elsewhere on the board
VCC: U2.A1, U2.B8, U2.H8; also elsewhere on the board

## Code that names these connections

File Nordic Semiconductor/ble_peripheral/ble_app_emg/pca10028/s110/arm5/RTE/ads1291-2.h (part):

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#define	ADS1291_2_REGADDR_LOFF		 			0x03			///< Lead-off control register. Controls lead-off frequency, magnitude, and threshold.
#define	ADS1291_2_REGADDR_CH1SET		 		0x04			///< Channel 1 settings register. Controls channel 1 input mux, gain, and power-down.
#define	ADS1291_2_REGADDR_CH2SET		 		0x05			///< Channel 2 settings register (ADS1292x only). Controls channel 2 input mux, gain, and power-down.
#define	ADS1291_2_REGADDR_RLD_SENS	 		0x06			///< RLD sense selection. Controls PGA chop frequency, RLD buffer, and channels for RLD derivation.
#define	ADS1291_2_REGADDR_LOFF_SENS	 		0x07			///< Lead-off sense selection. Controls current direction and selects channels that will use lead-off detection.
#define	ADS1291_2_REGADDR_LOFF_STAT	 		0x08			///< Lead-off status register. Bit 6 controls clock divider. For bits 4:0, 0: lead on, 1: lead off.
#define	ADS1291_2_REGADDR_RESP1		 			0x09			///< Respiration 1 (ADS1292R only). See datasheet.
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/**
 *  \brief Bit mask definitions for CONFIG2.INT_TEST (test signal on/off).
 */
#define	ADS1291_2_REG_CONFIG2_CAL_AMP_VREF_DIV_2_4_MV		(0<<1)		///< Calibration signal amplitude is 1 x (VREFP - VREFN)/(2.4 mV).
#define	ADS1291_2_REG_CONFIG2_CAL_AMP_2VREF_DIV_2_4_MV	(1<<1)		///< Calibration signal amplitude is 2 x (VREFP - VREFN)/(2.4 mV).

/**
 *  \brief Bit location and size definitions for CONFIG2.CLK_EN bit (oscillator output on CLK pin en/disabled).
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 */
#define	ADS1291_2_REG_CHNSET_NORMAL_ELECTRODE		0			///< Channel is connected to the corresponding positive and negative input pins.
#define	ADS1291_2_REG_CHNSET_INPUT_SHORTED			1			///< Channel inputs are shorted together. Used for offset and noise measurements.
#define	ADS1291_2_REG_CHNSET_RLD_MEASUREMENT		2			///< Used to measure RLD signal.
#define	ADS1291_2_REG_CHNSET_MVDD_SUPPLY				3			///< Used for measuring analog and digital supplies. See ADS1291/2 datasheet, p. 19.
#define	ADS1291_2_REG_CHNSET_TEMPERATURE_SENSOR	4			///< Measures device temperature. See ADS1291/2 datasheet, p. 19.
#define	ADS1291_2_REG_CHNSET_TEST_SIGNAL				5			///< Measures calibration signal. See ADS1291/2 datasheet, pp. 17 and 41.
#define	ADS1291_2_REG_CHNSET_RLD_DRP						6			///< Connects positive side of channel to RLD output.
#define	ADS1291_2_REG_CHNSET_RLD_DRM						7 		///< Connects negative side of channel to RLD output.
#define	ADS1291_2_REG_CHNSET_RLD_DRPM						8 		///< Connects both sides of channel to RLD output.
#define	ADS1291_2_REG_CHNSET_IN3								9 		///< Connects INxP/INxM of channel to IN3P/IN3M, respectively.

/**
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#define ADS1291_2_REGDEFAULT_LOFF				0x00			///< 95%/5% LOFF comparator threshold, DC lead-off at 6 nA	
#define ADS1291_2_REGDEFAULT_CH1SET			0x65			///< Channel on, G=12, test signal
#define ADS1291_2_REGDEFAULT_CH2SET			0x91			///< Channel off, G=1, input short
#define ADS1291_2_REGDEFAULT_RLD_SENS 	0x23			///< Chop @ fmod/16, RLD buffer on, LOFF off, RLD derivation from CH1 P+N
#define ADS1291_2_REGDEFAULT_LOFF_SENS	0x00			///< Current source @ IN+, sink @ IN-, all LOFF channels disconnected
#define ADS1291_2_REGDEFAULT_LOFF_STAT	0x00			///< Fmod = fclk/4 (for fclk = 512 kHz)
#define ADS1291_2_REGDEFAULT_RESP1			0x02			///< Resp measurement disabled
#define ADS1291_2_REGDEFAULT_RESP2			0x07			///< Offset calibration disabled, RLD internally generated
#define ADS1291_2_REGDEFAULT_GPIO				0x00			///< All GPIO set to output, logic low

/**************************************************************************************************************************************************
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 *	\brief Enable continuous data output.
 *
 * This function sends the RDATAC opcode, which makes conversion data immediately available
 * to the host as soon as the DRDY pin goes low. The host need only send SCLKs to retrieve
 * the data, rather than starting with a RDATA command. Registers cannot be read or written
 * (RREG or WREG) in this mode. Cancel continuous read mode using ads1291_2_stop_rdatac().
 *
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
## Commit log

2015-07-07 :space_invader: Added .gitattributes & .gitignore files
2015-07-07 Repository for stretchable circuit development in the Yeo Lab
2015-07-08 Corrected misplaced/named PCB file for ion sensor

Notices in the files:
Nordic Semiconductor/ble_peripheral/ble_app_emg/pca10028/s110/arm5/RTE/ads1291-2.h:
Copyright (c) 2015 Graham Kelly
